# IAR project STM3210E-EVAL_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\FWLib\library\inc; ..\..\..\USBLib\library\inc; ..\..\fatfs
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: STM32_ov7670_Demo.hex
  ILINK.IlinkOutputFile: STM3210E-EVAL_Demo.OUT
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../../FWLib/library/src/: stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../../source/: cc932.c delay.c diskio.c ff.c hw_config.c ILI9320.C main.c ov7670.c RTC_Time.c sccb.c SPI_SD_driver.c stm32f10x_it.c Touch.c
